# Keil uVision project Tamlate.uvprojx, settings and files
target LED (6150000::V6.15::ARMCLANG)
  device: GD32F103CB GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Tamlate +hex
  c flags: OneElfS=1 v6Lang=3 v6LangP=3
  c define: USE_STDPERIPH_DRIVER
  c include: .\USER;.\BSP\LED;.\BSP\TIMER;.\BSP\TIMER_LED;.\BSP\USART;.\LIB\inc;.\LIB\CMSIS\Include;.\BSP\ADC;.\BSP\DAC5311
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/: main.c signal_processing.c adc_handler.c measurement.c
  group BSP
    ./BSP/LED/: led.c
    ./BSP/TIMER/: timer.c
    ./BSP/USART/: usart.c
    ./BSP/ADC/: adc.c
    ./BSP/DAC5311/: dac5311.c
    ./BSP/DDS/: dds.c
    ./BSP/SINE/: sine_table.c
    ./BSP/DMA/: dma.c
    ./BSP/TIMER_LED/: timer_led.c
  group LIB
    ./LIB/src/: gd32f10x_adc.c gd32f10x_dac.c gd32f10x_dma.c gd32f10x_exti.c gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c system_gd32f10x.c startup_gd32f10x_hd.s
